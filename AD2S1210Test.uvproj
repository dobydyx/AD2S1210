# Keil uVision project AD2S1210Test.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ADuC7026 Analog Devices
  cpu: IRAM(0x10000-0x11FFF) IROM(0x80000-0x8F7FF) CLOCK(32768) CPUTYPE(ARM7TDMI)
  output: AD2S1210Test +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x80000 size 0xf800
  memory RVCT9: RAM 0x10000 size 0x2000
  group Source Group 1
    ./: ADuC702x.s AD2S1210.c AD2S1210Test.c ADuC7026Driver.c
